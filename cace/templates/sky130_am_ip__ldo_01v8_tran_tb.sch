** sch_path: cace/templates/sky130_am_ip__ldo_01v8_tran_tb.sch
**.subckt sky130_am_ip__ldo_01v8_tran_tb
R1 vout GND 360k m=1
vena ENA GND CACE[CACE{ENA}*CACE{DVDD}]
vref VREF_EXT GND CACE{VREF_EXT}
vsel SEL_EXT GND CACE[CACE{SEL_EXT}*CACE{AVDD}]
vavdd1 AVDD GND pulse 0 CACE{AVDD} 1u 1u
V0 AVSS GND 0
x1 AVDD vout AVSS ENA VREF_EXT SEL_EXT sky130_am_ip__ldo_01v8
**** begin user architecture code

.option savecurrents

.control

tran 100n 100u
save all

meas tran vout_op find v(vout) AT=100u
set wr_singlescale
remzerovec
wrdata CACE{simpath}/CACE{filename}_CACE{N}.data time V(AVDD) V(vout) vout_op

.endc




.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/combined/sky130.lib.spice CACE{corner}

.include CACE{PDK_ROOT}/CACE{PDK}/libs.ref/sky130_fd_sc_hvl/spice/sky130_fd_sc_hvl.spice

.include CACE{DUT_path}

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1


**** end user architecture code
**.ends
.GLOBAL GND
.end
